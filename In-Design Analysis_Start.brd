# Allegro board In-Design Analysis_Start.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CM_1V8: length 12.2
  TOP w0.3: J1.184 v1(29.72,31.65) ; v1(24.28,31.95) J1.183 20.93,31.95 20.88,32 C10.1 20.65,31.35 v1(21.52,31.35) J1.185 ; J1.186 v1(32.48,31.05)
  TOP w0.5: v1(39,21.85) R5.2 v1(37.9,20.95)
CM_3V3: length 11.3
  TOP w0.3: v1(24.28,29.55) J1.191 20.93,29.55 20.88,29.5 20.97,29.5 v1(21.52,28.95) J1.193 ; J1.194 v1(32.48,28.65) ; J1.192 v1(29.72,29.25)
  TOP w0.5: v1(34,21.85) R4.2 v1(35.1,20.95) ; 20.88,29.5 C3.1
CM_VBAT: length 12
  TOP w0.3: J1.197 v1(21.52,27.75) 21.1,27.75 20.35,27 ; J1.198 v1(32.48,27.45) ; C1.1 20.35,27 ; 20.35,27 21.25,27 21.4,27.15 J1.199 v1(24.28,27.15) ; J1.200 v1(29.72,26.85)
  TOP w0.5: v1(31.5,21.85) R1.2 v1(30.4,20.95)
CM_VDAC: length 25.2
  TOP w0.3: J1.190 v1(32.48,29.85) ; J1.189 v1(21.52,30.15)
  TOP w0.5: R6.2 v1(36.5,21.85)
  PWRB w0.3: v1(32.48,29.85) 25.15,29.85 24.85,30.15 v1(21.52,30.15)
  PWRB w0.5: v1(36.5,21.85) 36.5,27.2 33.85,29.85 v1(32.48,29.85)
DAC_2V5: length 12.7
  TOP w0.3: U2.5 42.1,14.7 C5.1 v1(42.65,15)
  TOP w0.5: R6.1 36.5,17.8 37.7,16.6 41.08,16.6 41.8,15.88 C5.1
  BOTTOM w0.5: v1(42.65,15) 43.2,15 PP4.1
DSI0_CN: length 32.3
  TOP w0.116: v1(3.06,68.08) 3.35,68.37 3.8,68.37 4.2,68.37 4.33,68.25 J10.8 ; J1.105 21.73,55.35 21.55,55.18 21.35,55.18 21.15,55.38 20.95,55.38 20.75,55.18 20.55,55.18 20.35,55.38 20.15,55.38 19.95,55.18 19.75,55.18 19.63,55.3 19.27,55.3 19.15,55.18 18.12,55.18 17.3,56 17.3,60.05 17.74,60.49 v1(18.16,60.49)
  BOTTOM w0.116: v1(18.16,60.49) 17.74,60.49 17.59,60.34 17.01,60.34 8.97,68.37 3.35,68.37 v1(3.06,68.08)
DSI0_CP: length 32.3
  TOP w0.116: v1(3.06,68.92) 3.35,68.63 3.7,68.63 4.2,68.63 4.33,68.75 J10.9 ; v1(17.56,61.09) 17.56,60.67 17.05,60.16 17.05,55.9 18.02,54.92 21.55,54.92 21.73,54.75 J1.107
  BOTTOM w0.116: v1(17.56,61.09) 17.56,60.67 17.48,60.59 17.11,60.59 9.07,68.63 3.35,68.63 v1(3.06,68.92)
DSI0_DN0: length 32.3
  TOP w0.116: J10.2 4.33,65.25 4.2,65.37 3.65,65.37 v1(3.36,65.08) ; J1.99 21.73,57.15 21.55,56.98 21.19,56.98 21.08,57.09 21.08,57.23 20.96,57.35 20.73,57.35 20.61,57.23 20.61,57.09 20.5,56.98 20.26,56.98 20.15,57.09 20.15,57.18 20.03,57.3 19.8,57.3 19.68,57.18 19.68,57.09 19.57,56.98 19.1,56.98 v1(18.8,57.27)
  BOTTOM w0.116: v1(18.8,57.27) 18.5,56.98 16.33,56.98 11.15,62.15 6.19,62.15 5.92,61.89 5.92,61.37 5.81,61.25 5.57,61.25 5.46,61.37 5.46,61.89 5.2,62.15 4.76,62.15 4.49,61.89 4.49,61.37 4.38,61.25 4.14,61.25 4.03,61.37 4.03,61.89 3.77,62.15 3.4,62.15 2,63.55 2,64.9 2.48,65.37 3.06,65.37 v1(3.36,65.08)
DSI0_DN1: length 32
  TOP w0.116: J10.5 5.67,66.75 5.8,66.87 6.78,66.87 8.1,65.55 8.1,65.05 7.13,64.08 v1(6.72,64.08) ; J1.93 21.73,58.95 21.55,58.78 21.35,58.78 21.15,58.98 20.95,58.98 20.75,58.78 20.55,58.78 20.35,58.98 20.15,58.98 19.95,58.78 19.1,58.78 v1(18.8,59.07)
  BOTTOM w0.116: v1(6.72,64.08) 7.13,64.08 8.5,65.45 9.5,65.45 10.13,64.83 10.29,64.83 10.7,65.23 11.07,65.23 11.38,64.92 11.38,64.55 10.97,64.14 10.97,63.98 11.14,63.82 11.3,63.82 11.71,64.22 12.08,64.22 12.39,63.91 12.39,63.54 11.99,63.13 11.99,62.97 12.15,62.81 12.31,62.81 12.72,63.21 13.09,63.21 13.4,62.9 13.4,62.53 13,62.12 13,61.96 13.16,61.79 13.32,61.79 13.73,62.2 14.1,62.2 14.41,61.89 14.41,61.52 14.01,61.11 14.01,60.95 16.18,58.78 18.5,58.78 v1(18.8,59.07)
DSI0_DP0: length 32.3
  TOP w0.116: J10.3 4.33,65.75 4.2,65.63 3.65,65.63 v1(3.36,65.92) ; J1.101 21.73,56.55 21.55,56.72 19.09,56.72 v1(18.8,56.43)
  BOTTOM w0.116: v1(3.36,65.92) 3.06,65.63 2.38,65.63 1.75,65 1.75,63.45 3.3,61.9 3.66,61.9 3.78,61.78 3.78,61.26 4.04,61 4.48,61 4.74,61.26 4.74,61.78 4.86,61.9 5.09,61.9 5.21,61.78 5.21,61.26 5.47,61 5.91,61 6.17,61.26 6.17,61.78 6.29,61.9 11.05,61.9 16.23,56.72 18.5,56.72 v1(18.8,56.43)
DSI0_DP1: length 32.1
  TOP w0.116: v1(7.31,63.49) 7.31,63.91 8.35,64.95 8.35,65.65 6.88,67.13 5.8,67.13 5.67,67.25 J10.6 ; J1.95 21.73,58.35 21.55,58.52 19.09,58.52 v1(18.8,58.23)
  BOTTOM w0.116: v1(7.31,63.49) 7.31,63.91 8.6,65.2 9.4,65.2 10.02,64.58 10.39,64.58 10.8,64.98 10.96,64.98 11.13,64.82 11.13,64.65 10.72,64.25 10.72,63.88 11.03,63.57 11.41,63.57 11.81,63.97 11.97,63.97 12.14,63.81 12.14,63.64 11.73,63.24 11.73,62.87 12.05,62.55 12.42,62.55 12.82,62.96 12.99,62.96 13.15,62.79 13.15,62.63 12.75,62.23 12.75,61.85 13.06,61.54 13.43,61.54 13.83,61.95 14,61.95 14.16,61.78 14.16,61.62 13.76,61.21 13.76,60.84 16.08,58.52 18.5,58.52 v1(18.8,58.23)
DSI1_CN: length 55.1
  TOP w0.115: v1(33.56,56.15) 33.28,56.44 32.44,56.44 32.25,56.25 J1.102
  TOP w0.116: v1(12.85,86.08) 12.55,86.37 5.8,86.37 5.67,86.25 J12.8
  BOTTOM w0.116: v1(12.85,86.08) 13.15,86.37 13.48,86.37 13.9,85.95 13.9,84.81 13.78,84.69 13.36,84.69 13.1,84.43 13.1,83.99 13.36,83.72 13.78,83.72 13.9,83.61 13.9,83.38 13.78,83.26 13.36,83.26 13.1,83 13.1,82.56 13.36,82.29 13.78,82.29 13.9,82.18 13.9,71 20.95,63.95 21.95,63.95 29.48,56.42 32.87,56.42 33.14,56.15 v1(33.56,56.15)
DSI1_CP: length 55.1
  TOP w0.115: J1.100 32.25,56.85 32.44,56.66 33.28,56.66 v1(33.56,56.94)
  TOP w0.116: v1(12.85,86.92) 12.55,86.63 5.8,86.63 5.67,86.75 J12.9
  BOTTOM w0.116: v1(33.56,56.94) 33.14,56.94 32.87,56.67 29.58,56.67 22.05,64.2 21.05,64.2 14.15,71.1 14.15,82.28 13.89,82.55 13.47,82.55 13.35,82.66 13.35,82.89 13.47,83.01 13.89,83.01 14.15,83.27 14.15,83.71 13.89,83.98 13.47,83.98 13.35,84.09 13.35,84.32 13.47,84.44 13.89,84.44 14.15,84.7 14.15,86.05 13.58,86.63 13.14,86.63 v1(12.85,86.92)
DSI1_DN0: length 54.9
  TOP w0.115: v1(33.56,57.96) 33.28,58.23 32.44,58.23 32.25,58.05 J1.96
  TOP w0.116: J12.2 5.67,83.25 5.8,83.37 14.9,83.37 v1(15.2,83.08)
  BOTTOM w0.116: v1(33.56,57.96) 33.14,57.96 32.87,58.22 29.53,58.22 21.95,65.8 21,65.8 16.75,70.05 16.75,77 16.63,77.12 15.86,77.12 15.6,77.38 15.6,77.82 15.86,78.09 16.63,78.09 16.75,78.2 16.75,78.43 16.63,78.55 15.86,78.55 15.6,78.81 15.6,79.25 15.86,79.52 16.63,79.52 16.75,79.63 16.75,79.86 16.63,79.98 15.86,79.98 15.6,80.24 15.6,80.68 15.86,80.95 16.63,80.95 16.75,81.06 16.75,82.55 15.93,83.37 15.5,83.37 v1(15.2,83.08)
DSI1_DN1: length 55.2
  TOP w0.115: J1.120 32.25,50.85 32.44,51.03 33.28,51.03 v1(33.56,50.76)
  TOP w0.116: J12.5 5.67,84.75 5.8,84.87 6.22,84.87 6.67,84.87 v1(6.97,84.58)
  BOTTOM w0.116: v1(33.56,50.76) 33.14,50.76 32.87,51.02 29.52,51.02 21.95,58.6 21.15,58.6 9.25,70.5 9.25,80.08 9.13,80.19 8.86,80.19 8.6,80.45 8.6,80.89 8.86,81.16 9.13,81.16 9.25,81.27 9.25,81.51 9.13,81.62 8.86,81.62 8.6,81.88 8.6,82.32 8.86,82.59 9.13,82.59 9.25,82.7 9.25,83.85 8.22,84.87 7.26,84.87 v1(6.97,84.58)
DSI1_DN2: length 55
  TOP w0.115: v1(33.56,52.55) 33.28,52.84 32.44,52.84 32.25,52.65 J1.114
  TOP w0.116: v1(6.97,87.58) 6.67,87.87 5.8,87.87 5.67,87.75 J12.11
  BOTTOM w0.116: v1(33.56,52.55) 33.14,52.55 32.87,52.82 29.63,52.82 22.1,60.35 21.1,60.35 10.45,71 10.45,86.15 8.73,87.87 7.26,87.87 v1(6.97,87.58)
DSI1_DN3: length 55
  TOP w0.115: J1.108 32.25,54.45 32.44,54.63 33.28,54.63 v1(33.56,54.36)
  TOP w0.116: J12.14 5.67,89.25 5.8,89.37 7.75,89.37 v1(8.05,89.08)
  BOTTOM w0.116: v1(8.05,89.08) 8.35,89.37 8.87,89.37 11.65,86.59 11.65,71.25 20.65,62.25 21.95,62.25 29.57,54.62 32.87,54.62 33.14,54.36 v1(33.56,54.36)
DSI1_DP0: length 54.9
  TOP w0.115: J1.94 32.25,58.65 32.44,58.47 33.28,58.47 v1(33.56,58.74)
  TOP w0.116: v1(15.2,83.92) 14.9,83.63 5.8,83.63 5.67,83.75 J12.3
  BOTTOM w0.116: v1(15.2,83.92) 15.49,83.63 16.03,83.63 17,82.65 17,80.96 16.74,80.69 15.97,80.69 15.85,80.58 15.85,80.35 15.97,80.23 16.74,80.23 17,79.97 17,79.53 16.74,79.26 15.97,79.26 15.85,79.15 15.85,78.92 15.97,78.8 16.74,78.8 17,78.54 17,78.1 16.74,77.83 15.97,77.83 15.85,77.72 15.85,77.49 15.97,77.37 16.74,77.37 17,77.11 17,70.15 21.1,66.05 22.05,66.05 29.63,58.48 32.87,58.48 33.14,58.74 v1(33.56,58.74)
DSI1_DP1: length 55.2
  TOP w0.115: J1.118 32.25,51.45 32.44,51.27 33.28,51.27 v1(33.56,51.54)
  TOP w0.116: J12.6 5.67,85.25 5.8,85.13 6.32,85.13 6.67,85.13 v1(6.97,85.42)
  BOTTOM w0.116: v1(6.97,85.42) 7.26,85.13 8.32,85.13 9.5,83.95 9.5,82.6 9.24,82.34 8.97,82.34 8.85,82.22 8.85,81.99 8.97,81.87 9.24,81.87 9.5,81.61 9.5,81.17 9.24,80.91 8.97,80.91 8.85,80.79 8.85,80.56 8.97,80.44 9.24,80.44 9.5,80.18 9.5,70.6 21.25,58.85 22.05,58.85 29.62,51.28 32.87,51.28 33.14,51.54 v1(33.56,51.54)
DSI1_DP2: length 55
  TOP w0.115: v1(33.56,53.34) 33.28,53.06 32.44,53.06 32.25,53.25 J1.112
  TOP w0.116: J12.12 5.67,88.25 5.8,88.13 6.67,88.13 v1(6.97,88.42)
  BOTTOM w0.116: v1(33.56,53.34) 33.14,53.34 32.87,53.07 29.73,53.07 22.2,60.6 21.2,60.6 10.7,71.1 10.7,86.25 8.83,88.13 7.26,88.13 v1(6.97,88.42)
DSI1_DP3: length 55
  TOP w0.115: v1(33.56,55.14) 33.28,54.87 32.44,54.87 32.25,55.05 J1.106
  TOP w0.116: v1(8.05,89.92) 7.75,89.63 5.8,89.63 5.67,89.75 J12.15
  BOTTOM w0.116: v1(33.56,55.14) 33.14,55.14 32.87,54.88 29.67,54.88 22.05,62.5 20.75,62.5 11.9,71.35 11.9,86.7 8.97,89.63 8.35,89.63 v1(8.05,89.92)
EMMC_DISABLE_N: length 137.4
  TOP w0.2: Q1.3 83.03,13 83.4,13.38 83.4,93.4 82.3,94.5 61.7,94.5 60.1,92.9 50.3,92.9 44.9,87.5 35.5,87.5 33.15,89.85 J1.2
GPIO0: length 58.3
  TOP w0.2: J1.3 v1(24.28,89.55)
  BOTTOM w0.2: v1(24.28,89.55) 41.8,89.55 45.7,93.45 61.65,93.45 63.55,91.55 76.95,91.55 J5.1
GPIO0-27_VREF: length 45.2
  TOP w0.3: J1.40 v1(29.72,78.45) ; 20.8,78.75 C13.1 J1.39 v1(24.28,78.75)
  TOP w1: R7.1 v1(53.65,96.5)
  PWRB w1: v1(53.65,96.5) 43.55,96.5 29.72,82.67 v1(29.72,78.45) 25.45,78.45 25.15,78.75 v1(24.28,78.75)
GPIO1: length 59.1
  TOP w0.2: J1.5 v1(24.8,88.95)
  BOTTOM w0.2: J5.3 76.94,89 63.95,89 60.05,92.9 46.75,92.9 42.8,88.95 v1(24.8,88.95)
GPIO2: length 60.3
  TOP w0.2: J1.9 v1(24.28,87.75)
  BOTTOM w0.2: J5.5 76.93,86.45 61.8,86.45 55.85,92.4 48.7,92.4 44.05,87.75 v1(24.28,87.75)
GPIO3: length 57.1
  TOP w0.2: J1.11 v1(24.8,87.15)
  BOTTOM w0.2: v1(24.8,87.15) 50.65,87.15 51.6,86.2 58.6,86.2 60.8,84 77.02,84 J5.7
GPIO4: length 57.7
  TOP w0.2: J1.15 v1(25.2,85.95)
  BOTTOM w0.2: v1(25.2,85.95) 50.55,85.95 50.95,85.55 57.85,85.55 62,81.4 76.96,81.4 J5.9
GPIO5: length 58.6
  TOP w0.2: J1.17 v1(24.65,85.35)
  BOTTOM w0.2: J5.11 76.95,78.85 63.15,78.85 57.15,84.85 25.95,84.85 25.45,85.35 v1(24.65,85.35)
GPIO6: length 59.2
  TOP w0.2: J1.21 v1(25.3,84.15)
  BOTTOM w0.2: J5.13 76.89,76.25 63.3,76.25 55.4,84.15 v1(25.3,84.15)
GPIO7: length 59.9
  TOP w0.2: J1.23 v1(24.7,83.55)
  BOTTOM w0.2: v1(24.7,83.55) 25.04,83.21 54.29,83.21 63.7,73.8 76.98,73.8 J5.15
GPIO8: length 60.5
  TOP w0.2: J1.27 v1(25.05,82.35)
  BOTTOM w0.2: v1(25.05,82.35) 25.5,81.9 53.2,81.9 63.9,71.2 76.92,71.2 J5.17
GPIO9: length 61.3
  TOP w0.2: J1.29 v1(24.45,81.75)
  BOTTOM w0.2: v1(24.45,81.75) 24.8,81.4 51.2,81.4 63.9,68.7 76.96,68.7 J5.19
GPIO10: length 61.8
  TOP w0.2: J1.33 v1(25.05,80.55)
  BOTTOM w0.2: v1(25.05,80.55) 25.39,80.21 50.04,80.21 64.05,66.2 77,66.2 J5.21
GPIO11: length 62.6
  TOP w0.2: J1.35 v1(24.28,79.95)
  BOTTOM w0.2: J5.23 76.99,63.65 64.1,63.65 48.14,79.61 24.61,79.61 v1(24.28,79.95)
GPIO12: length 60.9
  TOP w0.2: J1.45 v1(24.95,73.35)
  BOTTOM w0.2: J5.25 76.98,61.1 63.85,61.1 52.05,72.9 25.4,72.9 v1(24.95,73.35)
GPIO13: length 61.7
  TOP w0.2: J1.47 v1(24.45,72.75)
  BOTTOM w0.2: v1(24.45,72.75) 24.85,72.35 49.5,72.35 63.25,58.6 77.02,58.6 J5.27
GPIO14: length 62.3
  TOP w0.2: J1.51 v1(25.05,71.55)
  BOTTOM w0.2: v1(25.05,71.55) 25.4,71.2 48.55,71.2 63.75,56 76.96,56 J5.29
GPIO15: length 63.1
  TOP w0.2: J1.53 v1(24.45,70.95)
  BOTTOM w0.2: J5.31 77,53.5 63.7,53.5 46.6,70.6 24.8,70.6 v1(24.45,70.95)
GPIO16: length 63.6
  TOP w0.2: J1.57 v1(25,69.75)
  BOTTOM w0.2: J5.33 76.99,50.95 63.75,50.95 45.29,69.41 43.85,69.41 25.34,69.41 v1(25,69.75)
GPIO17: length 64.4
  TOP w0.2: J1.59 v1(24.28,69.15)
  BOTTOM w0.2: J5.35 76.98,48.4 63.7,48.4 43.29,68.81 24.61,68.81 v1(24.28,69.15)
GPIO18: length 65
  TOP w0.2: J1.63 v1(25.05,67.95)
  BOTTOM w0.2: v1(25.05,67.95) 25.39,67.61 41.64,67.61 63.45,45.8 76.92,45.8 J5.37
GPIO19: length 65.8
  TOP w0.2: J1.65 v1(24.28,67.35)
  BOTTOM w0.2: v1(24.28,67.35) 24.61,67.01 39.79,67.01 63.5,43.3 76.96,43.3 J5.39
GPIO20: length 66.4
  TOP w0.2: J1.69 v1(24.85,66.15)
  BOTTOM w0.2: v1(24.85,66.15) 25.19,65.81 38.34,65.81 63.4,40.75 76.95,40.75 J5.41
GPIO21: length 67.2
  TOP w0.2: J1.71 v1(24.28,65.55)
  BOTTOM w0.2: J5.43 76.99,38.25 63.25,38.25 36.29,65.21 24.61,65.21 v1(24.28,65.55)
GPIO22: length 67.7
  TOP w0.2: J1.75 v1(26.25,64.35)
  BOTTOM w0.2: v1(26.25,64.35) 26.59,64.01 35.59,64.01 63.85,35.75 77.03,35.75 J5.45
GPIO23: length 69.5
  TOP w0.2: J1.77 v1(25.5,63.75)
  BOTTOM w0.2: J5.47 76.92,33.1 63.85,33.1 62.42,34.53 62.42,36.08 35.09,63.41 25.84,63.41 v1(25.5,63.75)
GPIO24: length 70.8
  TOP w0.2: J1.81 v1(28.9,62.55)
  BOTTOM w0.2: v1(28.9,62.55) 29.24,62.21 34.99,62.21 61.18,36.02 61.18,33.17 63.85,30.5 76.86,30.5 J5.49
GPIO25: length 72.4
  TOP w0.2: J1.83 v1(28.15,61.95)
  BOTTOM w0.2: J5.51 76.85,27.95 63.95,27.95 60.14,31.76 60.14,35.96 34.49,61.61 28.49,61.61 v1(28.15,61.95)
GPIO26: length 73.8
  TOP w0.2: J1.87 v1(28.35,60.75)
  BOTTOM w0.2: J5.53 76.89,25.45 63.85,25.45 58.8,30.5 58.8,36.15 34.55,60.4 30.3,60.4 29.95,60.75 v1(28.35,60.75)
GPIO27: length 75.2
  TOP w0.2: J1.89 v1(29.3,60.15)
  BOTTOM w0.2: v1(29.3,60.15) 29.64,59.81 33.94,59.81 57.95,35.8 57.95,29 63.95,23 76.98,23 J5.55
GPIO28: length 39.5
  TOP w0.2: 34.15,82.05 54.55,82.05 63.15,90.64 63.34,90.64 J6.1 ; 34.15,82.05 34.19,82.08 R27.1 ; 34.15,82.05 J1.28
GPIO28-45_VREF: length 43.6
  TOP w0.3: v1(24.28,74.55) J1.41 C14.1 20.8,74.55 ; J1.42 v1(29.72,74.25)
  TOP w1: R8.1 v1(53.65,94.5)
  PWRB w1: v1(53.65,94.5) 49.97,94.5 v1(29.72,74.25) 29.42,74.55 v1(24.28,74.55)
GPIO29: length 38.7
  TOP w0.2: 34.15,81.45 J1.30 ; 34.15,81.45 54.45,81.45 63.29,90.29 J6.3 ; 34.15,81.45 34.19,81.42 R26.1
GPIO30: length 37.5
  TOP w0.2: J1.34 57.76,80.25 63.06,85.56 63.34,85.56 J6.5
GPIO31: length 36.7
  TOP w0.2: J1.36 57.65,79.65 63.21,85.21 J6.7
GPIO32: length 38.4
  TOP w0.2: J1.46 54.55,73.05 61.98,80.48 63.34,80.48 J6.9
GPIO33: length 37.6
  TOP w0.2: J1.48 54.45,72.45 62.13,80.13 J6.11
GPIO34: length 37.1
  TOP w0.2: J1.52 59.19,71.25 J6.13
GPIO35: length 36.3
  TOP w0.2: J1.54 61.13,70.65 J6.15
GPIO36: length 35.7
  TOP w0.2: J1.58 62.47,69.45 J6.17
GPIO37: length 34.9
  TOP w0.2: J1.60 64.41,68.85 J6.19
GPIO38: length 34.5
  TOP w0.2: J1.64 64.28,67.65 64.5,67.43 J6.21
GPIO39: length 35.3
  TOP w0.2: J6.23 63.37,67.05 J1.66
GPIO40: length 35.9
  TOP w0.2: J1.70 62.03,65.85 J6.25
GPIO41: length 36.7
  TOP w0.2: J1.72 60.09,65.25 J6.27
GPIO42: length 37.2
  TOP w0.2: J6.29 58.75,64.05 J1.76
GPIO43: length 38
  TOP w0.2: J1.78 56.81,63.45 J6.31
GPIO44: length 39.2
  TOP w0.2: J1.82 34.2,62.25 ; 34.2,62.25 55.47,62.25 J6.33 ; 34.2,62.25 34.19,62.27 R29.1
GPIO45: length 40
  TOP w0.2: 37.45,61.65 53.53,61.65 J6.35 ; 37.45,61.65 J1.84 ; 37.45,61.65 37.47,61.63 R28.1
GPIO46_1V8: length 31.3
  TOP w0.2: v1(11,60.85) R18.2 11,61.52 9.93,61.52 9.8,61.65 Q4.3 ; J1.88 33.45,60.45 v1(34,61)
  PWRB w0.2: v1(34,61) 33.1,60.1 31,60.1 29.85,58.95 28.35,58.95 24.9,62.4 12.55,62.4 v1(11,60.85)
GPIO47_1V8: length 86
  TOP w0.2: J1.90 52.15,59.85 63.65,48.35 69.3,48.35 72.75,44.9 72.75,19.45 79.98,12.22 79.98,11 R11.2 Q2.1
GPIO47_CTL_1V8: length 13.5
  TOP w0.2: R11.1 R10.2 ; R11.1 79.02,11 ; R11.1 v1(78.15,11)
  BOTTOM w0.2: J5.59 81.65,15.75 81.65,13.45 80.5,12.3 79.45,12.3 v1(78.15,11)
H5V: length 20.9
  TOP w0.2: U4.C1 v1(13.42,55.9) ; J13.18 7.3,56.5 v1(7.1,56.3) ; Q3.1 v1(15.02,54) ; U4.A1 v1(13.42,55.1)
  TOP w0.3: C16.1 15.34,58.52 14.75,57.92 U3.2 14.75,57.48 13.79,56.51 13.79,56.27 v1(13.42,55.9)
  PWRT w0.3: v1(15.02,54) 13.85,54 13.42,54.43 v1(13.42,55.1) v1(13.42,55.9) 13.42,56.65 13.02,57.05 7.85,57.05 v1(7.1,56.3)
  BOTTOM w0.5: v1(15.02,54) 15.02,52.52 PP10.1
HDMI_CEC: length 26.4
  TOP w0.2: J1.171 v1(20.6,35.55) ; R15.1 14.52,55.38 14.9,55 Q3.2 v1(16.75,55)
  PWRT w0.2: v1(16.75,55) 16.75,51.4 20.6,47.55 v1(20.6,35.55)
HDMI_CK_N: length 13.5
  TOP w0.116: J13.12 11.56,53.5 11.94,53.13 19.72,53.13 19.97,53.38 21.55,53.38 21.73,53.55 J1.111
HDMI_CK_P: length 13.5
  TOP w0.116: J13.10 11.56,52.5 11.94,52.87 19.82,52.87 20.07,53.12 21.55,53.12 21.73,52.95 J1.113
HDMI_D0_N: length 13.3
  TOP w0.116: J1.117 21.73,51.75 21.71,51.74 11.83,51.74 11.56,52 J13.9
HDMI_D0_P: length 13.5
  TOP w0.116: J1.119 21.73,51.15 21.39,51.48 12.05,51.48 11.56,51 J13.7
HDMI_D1_N: length 13.5
  TOP w0.116: J1.123 21.73,49.95 21.55,49.78 20.17,49.78 19.82,50.13 11.94,50.13 11.56,50.5 J13.6
HDMI_D1_P: length 13.5
  TOP w0.116: J1.125 21.73,49.35 21.55,49.52 20.07,49.52 19.72,49.87 11.94,49.87 11.56,49.5 J13.4
HDMI_D2_N: length 13.7
  TOP w0.116: J13.3 11.56,49 11.94,48.63 19.17,48.63 19.82,47.98 21.55,47.98 21.73,48.15 J1.129
HDMI_D2_P: length 13.7
  TOP w0.116: J13.1 11.56,48 11.94,48.37 19.07,48.37 19.72,47.72 21.55,47.72 21.73,47.55 J1.131
HDMI_HPD: length 13.4
  TOP w0.2: Q4.1 6.8,62.5 5.9,61.6 5.9,58.3 7.2,57 J13.19 11.37,57 11.95,56.42 11.95,56.18 12.1,56.03 U4.C3
HDMI_SCL: length 35.2
  TOP w0.2: v1(7.55,54.8) 8.01,54.8 8.21,55 J13.15 11.27,55 11.37,55.1 U4.A3 ; J1.175 v1(20.6,34.35)
  PWRT w0.2: v1(20.6,34.35) 19.85,34.35 19,35.2 19,46.6 10.8,54.8 v1(7.55,54.8)
HDMI_SDA: length 35.2
  TOP w0.2: v1(7.55,55.5) J13.16 U4.B3 ; J1.173 v1(21.2,34.95)
  PWRT w0.2: v1(21.2,34.95) 20.15,34.95 19.75,35.35 19.75,46.95 11.2,55.5 v1(7.55,55.5)
RUN: length 63.5
  TOP w0.2: J1.177 v1(24.28,33.75)
  BOTTOM w0.2: v1(24.28,33.75) 25.33,34.8 36.8,34.8 37.8,33.8 52.8,33.8 57.15,29.45 57.15,27.2 63.9,20.45 76.97,20.45 J5.57
TVDAC: length 41.8
  TOP w0.125: J1.166 39.85,37.05 57.73,19.17 J6.59
USB_DM: length 18.3
  TOP w0.136: U5.2 25.3,21.95 25.37,22.02 25.37,35.32 25.24,35.46 25.14,35.46 25,35.6 25,35.87 25.14,36 25.24,36 25.37,36.14 25.37,36.43 24.88,36.92 24.25,36.92 24.08,36.75 J1.167
USB_DP: length 18.3
  TOP w0.136: J1.165 24.08,37.35 24.25,37.18 24.98,37.18 25.63,36.53 25.63,22.02 25.7,21.95 U5.1
USB_OTGID: length 46.2
  TOP w0.2: 63.25,24.25 61.69,22.68 R12.2 ; 63.25,24.25 J6.55 ; 63.25,24.25 v1(55.4,32.1) ; J1.168 38.75,36.45 v1(39.9,35.3)
  BOTTOM w0.2: v1(39.9,35.3) 52.2,35.3 v1(55.4,32.1)
USBA_DM: length 10.4
  TOP w0.136: U5.6 25.3,19.71 25.37,19.64 25.37,18.07 28.37,15.07 28.37,12.37 J14.2
USBA_DP: length 10.4
  TOP w0.136: U5.7 25.7,19.71 25.63,19.64 25.63,18.17 28.63,15.17 28.63,12.37 J14.3
USBB_DM: length 25.1
  TOP w0.136: J15.2 13.35,5.88 13.55,6.08 13.55,17.15 17.13,20.73 24.14,20.73 24.21,20.8 U5.4
USBB_DP: length 25.1
  TOP w0.136: U5.5 24.21,20.4 24.14,20.47 23.85,20.47 23.71,20.34 23.71,20.34 23.58,20.2 23.31,20.2 23.17,20.34 23.17,20.34 23.03,20.47 22.76,20.47 22.63,20.34 22.63,20.34 22.49,20.2 22.22,20.2 22.08,20.34 22.08,20.34 21.95,20.47 17.23,20.47 13.8,17.05 13.8,6.08 14,5.88 J15.3
VC_TCK: length 91.1
  TOP w0.2: J1.180 v1(35.75,32.85)
  PWRT w0.2: v1(35.75,32.85) 35.75,89.85 31.5,94.1 16.6,94.1 14.4,96.3 14.4,99.89 J7.9
VC_TDI: length 86.5
  TOP w0.2: J1.174 v1(37.9,34.65)
  PWRT w0.2: J7.3 22,99.91 22,97.8 23,96.8 33.3,96.8 37.9,92.2 v1(37.9,34.65)
VC_TDO: length 88.9
  TOP w0.2: J1.178 v1(37.2,33.45)
  PWRT w0.2: J7.5 19.5,99.87 19.5,97.1 20.7,95.9 33,95.9 37.2,91.7 v1(37.2,33.45)
VC_TMS: length 89.1
  TOP w0.2: J1.176 v1(36.4,34.05)
  PWRT w0.2: J7.7 16.9,99.93 16.9,96.6 18.5,95 32.3,95 36.4,90.9 v1(36.4,34.05)
VC_TRST_N: length 83.6
  TOP w0.2: J1.172 v1(38.5,35.25)
  PWRT w0.2: J7.1 30.13,101.17 38.5,92.8 v1(38.5,35.25)
VG0: length 27.3
  TOP w1: J3.3 67,102.7 66,103.7 63.48,103.7 56.45,96.67 R7.2
  PWRB w1: J3.3 67,103.4 ; 83.5,59.5 83.5,59.81 J5.28 ; 83.5,29.33 J5.52 ; 83,75.05 J5.16 ; 83.5,44.57 J5.40
VG1: length 27.8
  TOP w1: J3.4 67,97.57 66.23,96.8 59.9,96.8 57.6,94.5 R8.2
  PWRB w1: 71,59.5 70.69,59.81 J6.28 ; 70.93,44.57 J6.40 ; 70.83,29.33 J6.52 ; 70.95,75.05 J6.16 ; 67,96.5 J3.4
N1195355: length 5.3
  TOP w0.3: 47.8,5.42 R9.2 v1(47.8,3.3) D2.2
  BOTTOM w0.3: v1(47.8,3.3) 46.3,3.3 PP9.1
N1195439: length 56.2
  TOP w0.2: Q1.2 81.42,12.5 82.8,11.12 Q2.3 82.8,8.8 82.4,8.4 78.4,8.4 77.2,9.6 77.2,11.4 73.2,15.4 50.4,15.4 46.2,11.2 D2.1
N1202496: length 2.6
  TOP w0.2: U1.12 61.2,9.14 61.22,9.16 R2.2 C6.1
N1202592: length 3.1
  TOP w0.25: L1.1 63.2,6.83 U1.8
N1202604: length 3.1
  TOP w0.25: L2.1 55.8,8.18 U1.2
N1202780: length 6
  TOP w0.4: F1.1 71.7,6.7 J2.1
  TOP w0.5: F1.1 v1(71,9)
  BOTTOM w0.5: v1(71,9) PP1.1
N1203166: length 1.4
  TOP w0.3: C9.1 42.1,11.81 U2.4
N1203318: length 7.6
  TOP w0.3: R3.2 50.69,5.42 v1(52.8,3.3) D1.2
  BOTTOM w0.3: PP7.1 52.8,2.8 v1(52.8,3.3)
N1313759: length 3.6
  TOP w0.2: R25.1 C21.2 R22.2 56.94,7.29 56.95,7.28 U1.4
N1313939: length 3.6
  TOP w0.2: U1.10 62.05,7.72 62.06,7.71 64.8,7.71
N1329395: length 32.3
  TOP w0.2: 9.38,8.5 R20.2 10.18,8.5 10.47,8.2 Q5.3 v1(10.9,7.42) ; U5.10 26.85,21.2 v1(27.3,21.65)
  BOTTOM w0.2: v1(27.3,21.65) 26.45,22.5 20,22.5 12.5,15 12.5,9.02 v1(10.9,7.42) 10.38,7.94 10.38,8.12 PP11.1
N1357591: length 70.1
  TOP w0.2: R30.1 81.2,14.29 Q1.1 v1(80.2,13.5)
  BOTTOM w0.2: J4.2 21.2,17.2 48.5,17.2 50.9,14.8 78.9,14.8 v1(80.2,13.5)

## Copper pours and planes (outline as drawn)
1V8 on PWRT: 81,0.5 4,0.5 0.5,4 0.5,101 4,104.5 81,104.5 84.5,101 84.5,4 ; 4 cut-outs
3V3 on PWRB: 81,0.5 4,0.5 0.5,4 0.5,101 4,104.5 81,104.5 84.5,101 84.5,4 ; 11 cut-outs
5V on PWRT: 4,0.5 0.5,4 0.5,61 12,61 12.5,60.5 12.5,11.1 12.9,10.7 67.2,10.7 68.5,12 82,12 82.5,12.5 82.5,22.5 82,23 67,23 66.5,23.5 66.5,25 67,25.5 82,25.5 82.5,26 82.5,88.5 82,89 67,89 66.5,89.5 66.5,91.5 67,92 84.5,92 84.5,4 81,0.5 ; 1 cut-out
GND on TOP: 81,0.5 77.1,0.5 77.1,6 68.9,6 68.9,0.5 18.1,0.5 18.1,6 9.9,6 9.9,0.5 4,0.5 0.5,4 0.5,101 4,104.5 81,104.5 84.5,101 84.5,4 ; 8 cut-outs
GND on TOP: 60.5,13.3 60.5,8.8 60.4,8.8 60.4,6.2 60.15,6.2 60.15,2.25 58.5,2.25 58.5,5.75 58.6,5.75 58.6,8.8 58.85,8.8 58.85,13.3
GND on BOTTOM: 84.5,4 81,0.5 4,0.5 0.5,4 0.5,101 4,104.5 81,104.5 84.5,101 ; 36 cut-outs
GND on GNDT, GNDB: 81,0.5 4,0.5 0.5,4 0.5,101 4,104.5 81,104.5 84.5,101 84.5,4
CM_1V8 on PWRB: 21.3,32.2 21.3,30.8 33.8,30.8 37.2,27.4 37.2,20.6 40.3,20.6 40.3,28.2 36.3,32.2
CM_3V3 on PWRB: 21.3,29.8 21.3,28.4 32.7,28.4 33,28.1 33,20.6 35.7,20.6 35.7,27.1 33.4,29.4 32.3,29.4 31.8,29.5 24.9,29.5 24.6,29.8
CM_VBAT on PWRB: 21.3,28 21.3,26.6 30.1,26.6 30.1,20.6 32.7,20.6 32.7,28
VG0 on PWRB: 82.5,29 82.5,94 79.5,94 70.5,103 66.5,103 66,103.5 66,104.5 81,104.5 84.5,101 84.5,29 84,28.5 83,28.5
VG1 on PWRB: 66.5,97.5 66,97 66,96 66.5,95.5 69.5,95.5 70,95 70,29 70.5,28.5 71.5,28.5 72,29 72,97 71.5,97.5

Small or netless copper shapes (teardrops, artwork): 277 on TOP, 86 on BOTTOM, 22 on PWRT, 17 on PWRB

## Text on the board
BOTTOM: L06 - BOTTOM
User.Comments: TOP SOLDER MASK | BOTTOM SOLDER MASK
TOP: L01 - TOP
Package Geometry/Pastemask Top: TOP PASTE MASK
Ref Des/Silkscreen Top: GND | 5V0 | 3V3 | 1V8 | VG1 | VG0 | EN | USB SLAVE | DIS | BOOT ENABLE | CD1_SDA | CD1_SCL | CAM1_IO1 | CAM1_IO0 | CD0_SDA | CD0_SCL | CAM0_IO1 | CAM0_IO0 | 28 | 29 | 30 | 31 | 32 | 33 | 34 | 35 | 36 | 37 | 38 | 39 | 40 | 41 | 42 | 43 | 44 | 45 | VDD_CORE | USB_OTGID | TVDAC | 0 | 1 | 2 | 3 | 4 | 5 | 6 | 7 | 8 | 9 | 10 | 11 | 12 | 13 | 14 | 15 | 16 | 17 | 18 | 19 | 20 | 21 | 22 | 23 | 24 | 25 | 26 | 27 | RUN | VG0 SELCT | VG1 SELCT | GPIO47_CTL_1V8 | GPIOx BANK 1 | GPIOx BANK 0 | VC JTAG | Version 1.2 (c) Raspberry Pi 2014 | Raspberry Pi Compute Module IO Board | ACT | PWR | USB HOST | POWER IN | TOP COMPONENT LEGEND | DISP1 | DISP0 | CAM1 | CAM0 | RASPBERRY PI COMPUTE MODULE
GNDT: L02 - GND
PWRT: L03 - PWR/ROUTING
PWRB: L04 - PWR/ROUTING
GNDB: L05 - GND
DIMENSION: NONE | DRILL DWG / MECHANICAL | (ON TOP SIDE) | ADD MANUFACTURING CODES HERE
NCLEGEND-1-6: FIGURE | SIZE | 0.25 | 1.0 | 2.3 | 1.1 | 1.6 | 2.4 | 3.4 | 1.05x0.65 | 1.4x0.7 | 1.7x0.9 | 2.7x0.9 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILLIMETERS | PLATED | NON-PLATED | QTY | 450 | 143 | 2 | 1 | 4
